# Keil uVision project comm_convert.uvprojx, settings and files
target comm_convert (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G070KBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801DFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: comm_convert +hex
  AfterMake: fromelf --bin --output=com_convert.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Bsp;../Services;../Protocols;../App;../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8003800 size 0x1a800
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c iwdg.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Application/Bsp
    ../Bsp/: bsp_boot.h bsp_boot.c bsp_adc.c bsp_adc.h bsp_nv.c bsp_nv.h bsp_system.h bsp_system.c bsp_io.h bsp_io.c bsp_uart.h bsp_uart.c
  group Application/Services
    ../Services/: svc_boot.h svc_boot.c svc_poll.c svc_poll.h svc_identity.c svc_identity.h svc_telemetry.c svc_telemetry.h svc_relay.c svc_relay.h svc_sampling.c svc_sampling.h svc_params.c svc_params.h svc_gm800.c svc_gm800.h svc_serial.h svc_serial.c
  group Application/App
    ../App/: app_mode.c app_mode.h app_hik.c app_hik.h app_local.c app_local.h app_dto.c app_dto.h app_main.h app_main.c
  group Application/Config
    ../Config/: boot_config.h poll_config.h hik_config.h telemetry_types.h dto_config.h sampling_config.h params_config.h comm_params.c comm_params.h gm800_config.h comm_config.h
  group Application/Protocols
    ../Protocols/: proto_local.c proto_local.h proto_controller.c proto_controller.h proto_hik.c proto_hik.h proto_gm800.c proto_gm800.h
software components: CMSIS:CORE 4.3.0
